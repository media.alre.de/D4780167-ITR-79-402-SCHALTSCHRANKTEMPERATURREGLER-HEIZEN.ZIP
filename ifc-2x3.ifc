Properties of the parts of a building model (IFC2X3)

# File
Description: Temperaturregler für Normschienenmontage, -35…+15 °C, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: D4780167, Temperaturregler für Normschienenmontage, -35…+15 °C
In: Raum
Description: Elektronischer Temperaturregler zur Regelung und Überwachung der Temperatur in Hallen, Gewächshäusern und Fußbodenheizungen. Das Gerät verfügt über eine Fühlerbruch- und Fühlerkurzschlusssicherung sowie eine Anzeige "Heizen". Fühler gehören nicht zum Lieferumfang. Alle Fühler mit der Nummer 1 können eingesetzt werden, z. B. KF-1. Die Hysterese ist einstellbar zwischen ca. 0,5…5 K.; Classification: EC001666 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: D4780167; ModelLabel: ITR 79.402; GlobalTradeItemNumber: 4050528026354; ProductURL: https://alre.de/produkt_D4780167
Pset_Specification - NominalLength: 0.086 m; NominalWidth: 0.0625 m; NominalDepth: 0.036 m; NetWeight: 0.157
Pset_ALRE_ETIM_Properties - Kontaktausführung: Wechsler (NO/NC); Nennschaltstrom bei 250 V, potentialfrei: 10; Bemessungsspannung: 230; Einstellbereich Komfort: -35; Schutzart (IP): IP20; Bautiefe: 62.5; Sensortyp: Fernfühler; ETIM-Klasse: EC001666; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-D4780167.pdf
